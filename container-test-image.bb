LICENSE = "MIT"
PREFERRED_PROVIDER_virtual/kernel = "linux-dummy"
IMAGE_FSTYPES = "container"
IMAGE_LINGUAS = ""

inherit core-image
